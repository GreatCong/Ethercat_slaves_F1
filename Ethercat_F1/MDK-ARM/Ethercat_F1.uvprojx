# Keil uVision project Ethercat_F1.uvprojx, settings and files
target Ethercat_F1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Ethercat_F1
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;            ../Drivers/STM32F1xx_HAL_Driver/Inc;            ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;            ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;            ../Drivers/CMSIS/Include;            ..\Hardware\EtherCAT\Hardware;            ..\Hardware\EtherCAT\Inc;            ..\Hardware\global;            ..\Hardware\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_it.c main.c gpio.c spi.c stm32f1xx_hal_msp.c tim.c usart.c
  group Ethercat/src
    ../Hardware/EtherCAT/src/: aoeappl.c bootmode.c coeappl.c diag.c ecataoe.c ecatappl.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c ecatsoe.c el9800appl.c el9800hw.c emcy.c eoeappl.c foeappl.c mailbox.c objdef.c sdoserv.c
  group Ethercat/hardware
    ../Hardware/EtherCAT/Hardware/: EXIT.c SPI1.c Timer.c
  group Gobal
    ../Hardware/global/: global.c
  group PWM
    ../Hardware/PWM/: PWM.c
software components: CMSIS:CORE 4.3.0
